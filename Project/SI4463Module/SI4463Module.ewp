# IAR project SI4463Module.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x80
  General.GenHeapSize: 0x00
  ICCSTM8.CCDefines: STM8S103; AUTOSTART_ENABLE=1; RADIO_DRIVER_EXTENDED_SUPPORT; xMMEM_CONF_SIZE=516
  ICCSTM8.CCIncludePath2: ; ../../OS-Core\; ../../Cpu/STM8A-S\; ../../Cpu/STM8A-S/inc\; ../../OS-Core/sys\; ../../OS-Core/lib\; ../../Platform/SI4463Module\; ../../Platform/SI4463Module/Radio\
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: SI4463Module.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Cpu/STM8A-S
    ../../Cpu/STM8A-S/src/: stm8s_adc1.c stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_can.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_tim5.c stm8s_tim6.c stm8s_uart1.c stm8s_uart2.c stm8s_uart3.c stm8s_wwdg.c
  group OS-Core/cfs
    ../../OS-Core/cfs/: cfs-coffee.c cfs-eeprom.c cfs-posix-dir.c cfs-posix.c cfs-ram.c cfs-xmem.c
  group OS-Core/lib
    ../../OS-Core/lib/: assert.c checkpoint.c crc16.c ctk-filedialog.c ctk-textentry-checkbox.c ctk-textentry-cmdline.c ctk-textentry-multiline.c gcr.c ifft.c libconio.c list.c me.c me_tabs.c memb.c mmem.c petsciiconv.c print-stats.c random.c ringbuf.c sensors.c settings.c strncasecmp.c trickle-timer.c
  group OS-Core/sys
    ../../OS-Core/sys/: arg.c autostart.c compower.c ctimer.c energest.c etimer.c mt.c process.c procinit.c profile-aggregates.c profile.c rtimer.c stimer.c timer.c timetable-aggregate.c timetable.c
  group Platform
    ../../Platform/SI4463Module/: bsp.c clock.c rtimer-arch.c
  group Platform/Radio
    ../../Platform/SI4463Module/Radio/: radio.c radio_comm.c radio_hal.c si446x_api_lib.c si446x_nirq.c
  group Project
    ./: main.c packetsbuf.c stm8s_it.c tasks.c
